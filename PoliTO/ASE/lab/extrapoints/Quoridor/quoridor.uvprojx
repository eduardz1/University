# Keil uVision project quoridor.uvprojx, settings and files
target Quoridor (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quoridor
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=5
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: main.c common.h
  group lib_SoC_board
    ./: system_LPC17xx.c
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group TP
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group utils
    ./utils/: dynarray.c dynarray.h stack.c stack.h
  group imgs
    ./imgs/: sprites.h wall.c cell.c player.c
  group button_EXINT
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group joystick
    ./joystick/: funct_joystick.c joystick.h lib_joystick.c
  group led
    ./led/: funct_led.c led.h lib_led.c
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group game
    ./game/: game.c game.h graphics.c graphics.h
software components: CMSIS:CORE 5.6.0
